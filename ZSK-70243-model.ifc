Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:37+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-70243
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Комплекс игровой детский, ZSK-70243 Игровой комплекс «Тройная Горка»
In: Площадка
Description: Комплекс игровой детский. Игровой комплекс «Тройная Горка»; Classification: 59.1.15.01-0242 Горка (Классификатор строительных ресурсов (КСР)); Material: Нержавеющая сталь, атмосферостойкий HDPE, армированные канат
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-70243; ModelReference: Игровой комплекс «Тройная Горка»; ProductionYear: 2026; ArticleNumber: ZSK-70243
ORION_Изделие - Артикул: ZSK-70243; Артикул прежний: SD-70243; Наименование: Игровой комплекс «Тройная Горка»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 10.4 x 4.0 м; Зона безопасности: 14.20 x 7.80 м; Высота свободного падения: 2.1 м; Возраст: для детей от 2 до 12 лет; Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; Цена: 4 500 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/play-complexes/346; Код КСИ: CPr>EDB030; Класс КСИ: Горка; Коды КСР: 59.1.15.01-0242 … 59.1.15.01-0305
ADSK - ADSK_Наименование: Игровой комплекс «Тройная Горка»; ADSK_Марка: ZSK-70243; ADSK_Код изделия: 59.1.15.01-0242; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; ADSK_URL страницы изделия: https://зск.рф/catalog/play-complexes/346
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 14.20 x 7.80 м; ZSK_Высота_свободного_падения: 2.1 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB030; ZSK_Артикул_прежний: SD-70243
Qto_ORION - Длина: 10400 mm; Ширина: 4000 mm; Высота: 0 mm
